require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:e41fa62dd129a0943224642482711f32d2788dc61557186cc542057defaaebcc"
