require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:8c3d9bef4a6dc2a98db589483dd46e4f314bf05a001b358c5b98e0a81f4f7a6d"
