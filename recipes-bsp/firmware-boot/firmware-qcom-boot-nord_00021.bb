require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:8dbb184a67e2763a4b9e9de17ebd0a1e76cb481918e085376f862535a648969f"
