require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:f80b359ee36b04f866680766b7c7ba22a1d4dacbafb4039861eb4e79897efaac"
