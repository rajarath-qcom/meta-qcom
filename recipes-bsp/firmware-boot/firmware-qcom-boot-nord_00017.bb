require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:3cafed0ebb88751cf2fd084952628d74fb25390b63d4157fbf8e08a43c5540c4"
