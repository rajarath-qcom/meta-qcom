require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:7f96d73512b5248562eb8e62d8fea93cc4556e5701a98133540d85f37a0af622"
