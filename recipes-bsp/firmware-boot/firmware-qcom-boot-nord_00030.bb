require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:1d84cc865c018f137bcc63c24151b76a49a5edb50f64b36307caf82ca7b46348"
