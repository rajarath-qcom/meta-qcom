require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:6e90213e31352c169e21bb5a3264b6d9d0db2cfcc387db52ea833e9cfa054330"
