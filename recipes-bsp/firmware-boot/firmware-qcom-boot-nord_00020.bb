require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:c92439b54f5710f762461057aa4ec6b94331f3e4079a404f287eb143312ef0bf"
