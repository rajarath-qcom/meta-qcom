require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:5e49f38cac8a94a372124b3c0f3c51d1fa707e88a71b37315492c1b52682051f"
