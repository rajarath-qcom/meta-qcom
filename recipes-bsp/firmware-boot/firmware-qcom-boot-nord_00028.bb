require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:763fa0f528febf7d2fa2ff85321d55b125b9cc7fc1adf0e8e64b259b1a630720"
