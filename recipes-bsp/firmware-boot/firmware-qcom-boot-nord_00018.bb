require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "sha256:63edee1639a0a41cca6f88cc919a606c990be13941a10a56ee02944289921074"
